<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\vive_tracker_stm32f103.ewp</path>
  </project>
  <batchBuild/>
</workspace>


